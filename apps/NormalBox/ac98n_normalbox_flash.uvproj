# Keil uVision project ac98n_normalbox_flash.uvproj, settings and files
target f98_NormalBox_flash (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: f98_flash +hex
  AfterMake: ./tools/load_flash.bat
  c flags: Optimize=9
  c define: TCFG_USE_FLASH_DEBUG,TCFG_NORMALBOX_CASE
  c include: .\code\include;..\..\include_lib;..\..\common\code\include
  link misc: REMOVEUNUSED
  group Start
    ../../common/start/: STARTUP_FLASH.A51
  group cpu
    ../../cpu/: adc.c boost.c burn.c charge.c io_wkup.c pmu.c pmu_wkup.c power_hw.c pulse_cnt.c pwm_led.c uart.c uart_key.c vout_inserdet.c seg_led.c
  group NormalBox
    ./code/: app_close.c app_common.c app_main.c board_config.c
  group common
    ../../common/code/: boost_optimize.c charge_optimize.c hall_det.c key.c power_det.c timer.c usb_det.c wireless.c extern_ntc_det.c inside_ntc_det.c
  group lib
    ../../lib/: f98.LIB
  group other
    ./tools/: load_flash.bat download_flash.bat isd_config.ini
